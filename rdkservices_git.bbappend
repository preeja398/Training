FILESEXTRAPATHS_prepend:="$(THISDIR)/files:"

SRC_URI +="\
           file://0001-create_patch-DisplayInfo.patch \
           file://0001-add-HelloWorld-in-rdkservices-PlatformImplementation.patch \
           file://0001-add-new-plugin-DisplayInfo.patch \
          "

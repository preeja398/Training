EXTRAPATHS_prepend:="$(THISDIR)/files:"

SRC_URI +="\
           file://0001-add-ID-in-Ids.patch \
          "
